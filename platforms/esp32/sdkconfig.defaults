## platforms/esp32/sdkconfig.defaults
```kconfig
# CONFIG_COMPILER_CXX_EXCEPTIONS is not set
# CONFIG_COMPILER_CXX_RTTI is not set
```
